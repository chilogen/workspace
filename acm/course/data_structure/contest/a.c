#include<stdio.h>
#include<string.h>
char al[26][10]={ \
{'@'}, \
{'8'}, \
{'('}, \
{'|',')'}, \
{'3'}, \
{'#'}, \
{'6'}, \
{'[','-',']'}, \
{'|'}, \
{'_','|'}, \
{'|','<'}, \
{'1'}, \
{'[',']','\\','/','[',']'}, \
{'[',']','\\','[',']'}, \
{'0'}, \
{'|','D'}, \
{'(',',',')'}, \
{'|','Z'}, \
{'$'}, \
{'\'',']','[','\''}, \
{'|','_','|'}, \
{'\\','/'}, \
{'\\','/','\\','/'}, \
{'}','{'}, \
{'`','/'}, \
{'2'}};
int main()
{
	
	//freopen("abc","r",stdin);
	char s;
	s=getchar();
	while(s!='\n')
	{
		if(s-'a'>=0&&'z'-s>=0)	printf("%s",al[s-'a']);
		else if(s-'A'>=0&&'Z'-s>=0)  printf("%s",al[s-'A']);
		else printf("%c",s);
		s=getchar();
	}
	//fclose(stdin);
	return 0;
}